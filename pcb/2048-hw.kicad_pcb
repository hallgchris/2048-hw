# Repository hallgchris/2048-hw

## KiCad design pcb/2048-hw.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 4u7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C7, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: SMAJ5.0A; D_SMA_Handsoldering
D2: Charging; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: Done; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: STATUS; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm_no1
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: UJC-HP-3-SMT-TR; CUI_UJC-HP-3-SMT-TR
J2: Battery; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J3: SWD; PinHeader_1x06_P2.54mm_Horizontal
JP1: BOOT0; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 39n; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1, R2, R6, R7, R8, R10, R18: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R9, R11, R17, R19, R21, R22: 2k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15, R16: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; E_SWITCH_EG2208
SW2: PUSH_A; SW_PUSH_6mm_H5mm
SW3: PUSH_B; SW_PUSH_6mm_H5mm
TP1: GND; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP2: 5V; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP3: BAT+; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP4: 3V3; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP5: X_MIN; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP6: X_MAX; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP7: Y_MIN; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP8: Y_MAX; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP9: PUSH_A; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP10: PUSH_B; TestPoint_THTPad_D1.5mm_Drill0.7mm
TP11: LED_DAT; TestPoint_THTPad_D1.5mm_Drill0.7mm
U1: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U2: MCP73831-2-OT; SOT-23-5
U3: AP2210N-3.3TRG1
U4: PSP_1000_JSTK; JOYSTICK-PSP1000
U5: LMV339; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
14_REF: R18.1, R19.2, U5.5 (+), U5.11 (+)
34_REF: R17.1, R18.2, U5.6 (-), U5.8 (-)
+3.3VA: C8.1, C9.1, L1.2, U1.5 (VDDA)
+3V3: C4.1, C5.1, C6.1, C7.1, C12.2, J3.1, JP1.1 (A), L1.1, R9.2, R17.2, TP4.1, U1.1 (VDD), U1.17 (VDD), U3.2 (VOUT), U4.2 (VCC), U5.3 (V+)
+5V: C1.1, D1.1 (K), J1.A9 (V-BUS), J1.B9 (V-BUS), R4.1, TP2.1, U2.4 (VDD)
BAT_ADC: R6.1, R7.2, U1.6 (PA0)
BOOT0: JP1.2 (B), R10.2, U1.31 (BOOT0)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, D1.2 (A), D4.1 (K), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.3 (VSS), D18.3 (VSS), D19.3 (VSS), D20.3 (VSS), D21.3 (VSS), J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J2.1, J3.6, R1.1, R2.1, R3.2, R5.1, R8.1, R10.1, R11.1, R19.1, SW2.1, SW3.1, TP1.1, U1.16 (VSS), U1.32 (VSS), U2.2 (VSS), U3.1 (GND), U4.4 (GND), U5.12 (V-)
JSTK_X: U4.1 (LEFT_RIGHT), U5.4 (-), U5.7 (+)
JSTK_Y: U4.3 (UP_DOWN), U5.9 (+), U5.10 (-)
LED_STATUS: D5.2 (A), U1.9 (PA3)
NRST: R15.2, U1.4 (NRST)
unnamed: D2.1 (K), D3.2 (A), U2.1 (STAT)
unnamed: D2.2 (A), R4.2
unnamed: D3.1 (K), R5.2
unnamed: D4.2 (A), R9.1
unnamed: D5.1 (K), R11.2
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D6.4 (DIN), R20.2
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), D17.4 (DIN)
unnamed: D17.2 (DOUT), D18.4 (DIN)
unnamed: D18.2 (DOUT), D19.4 (DIN)
unnamed: D19.2 (DOUT), D20.4 (DIN)
unnamed: D20.2 (DOUT), D21.4 (DIN)
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: J3.2, R13.1
unnamed: J3.3, R14.1
unnamed: J3.4, R15.1
unnamed: J3.5, R16.1
unnamed: R3.1, U2.5 (PROG)
unnamed: R7.1, R8.2
unnamed: R21.2, SW2.2
unnamed: R22.2, SW3.2
PUSH_A: C13.1, R21.1, TP9.1, U1.29 (PB6)
PUSH_B: C14.1, R22.1, TP10.1, U1.30 (PB7)
SPI1_MOSI: R20.1, TP11.1, U1.28 (PB5)
SWCLK: R13.2, U1.24 (PA14)
SWDIO: R14.2, U1.23 (PA13)
SWO: R16.2, U1.26 (PB3)
V_BAT: C3.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), D18.1 (VDD), D19.1 (VDD), D20.1 (VDD), D21.1 (VDD), R6.2, SW1.3, U3.3 (VIN)
V_BAT_IN: C2.2, J2.2, SW1.2, TP3.1, U2.3 (VBAT)
X_MAX: TP6.1, U1.19 (PA9), U5.1
X_MIN: TP5.1, U1.18 (PA8), U5.2
Y_MAX: TP8.1, U1.21 (PA11), U5.14
Y_MIN: TP7.1, U1.20 (PA10), U5.13

Notes on the sheet:
The stm32f303 has 40kOhm pull ups, forming an RC circuit with τ = 4ms.
Power supply
Microcontroller
Joystick
LED array
Pushbuttons
Mounting

Board: 2 copper layers, 60.0 x 93.0 mm, 98 parts (4 on the bottom side), 55 nets.

## Code that names these connections

File pcb/cubemx/cubemx.ioc (part):

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PA6.Mode=Full_Duplex_Master
Mcu.UserName=STM32F303K8Tx
PA9.GPIO_Label=Y_MAX
PA12.GPIOParameters=GPIO_Label,GPIO_PuPd
PA9.GPIOParameters=GPIO_PuPd,GPIO_Label
PA11.GPIOParameters=GPIO_PuPd,GPIO_Label
PA3.GPIOParameters=GPIO_Label
PA11.GPIO_Label=PUSH_B
PB0.GPIO_Label=X_MAX
RCC.HSEPLLFreq_Value=8000000
PA11.GPIO_PuPd=GPIO_PULLUP
PA9.GPIO_PuPd=GPIO_PULLUP
PA12.GPIO_Label=PUSH_A
PA13.Signal=SYS_JTMS-SWDIO
PB4.GPIOParameters=GPIO_Label,GPIO_Speed,GPIO_ModeDefaultOutputPP
PA12.Signal=GPIO_Input
PA8.GPIO_Label=Y_MIN
PB1.GPIO_PuPd=GPIO_PULLUP
PA9.Signal=GPIO_Input
PB6.Signal=I2C1_SCL
PB6.Mode=I2C
PA8.GPIOParameters=GPIO_PuPd,GPIO_Label
PA5.Signal=SPI1_SCK
RCC.HSE_VALUE=8000000
PB3.Mode=Trace_Asynchronous_SW
board=custom
PB4.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB0.GPIOParameters=GPIO_Label,GPIO_PuPd
PB4.GPIO_Label=EEPROM_WP
PA14.Mode=Trace_Asynchronous_SW
PB1.GPIO_Label=X_MIN
PB5.Mode=Full_Duplex_Master
PA0.Mode=IN1-Single-Ended
PB7.Signal=I2C1_SDA
PA8.Signal=GPIO_Input
PA13.Mode=Trace_Asynchronous_SW
Mcu.Name=STM32F303K(6-8)Tx
PA0.Signal=ADC1_IN1
PB3.Signal=SYS_JTDO-TRACESWO
RCC.SYSCLKFreq_VALUE=8000000
Mcu.Package=LQFP32
PB5.Signal=SPI1_MOSI
PA6.Signal=SPI1_MISO
PB1.Signal=GPIO_Input
PB7.Mode=I2C
PA11.Signal=GPIO_Input
PA14.Signal=SYS_JTCK-SWCLK
PA8.GPIO_PuPd=GPIO_PULLUP
PA12.GPIO_PuPd=GPIO_PULLUP
PB0.Signal=GPIO_Input
PB0.GPIO_PuPd=GPIO_PULLUP
PB4.Signal=GPIO_Output
PA3.GPIO_Label=LED_STATUS
PB4.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PA3.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label,GPIO_PuPd
PA5.Mode=Full_Duplex_Master

## Commit log

2020-12-31 Upload reference documtenation for stm32l4, mcp73831, usb C, battery
2020-12-31 Add initial charge controller and USB connection schematic
2021-01-01 Add 3v3 regulator circuit
2021-01-01 Tidy up library symbols
2021-01-01 Add barebones circuitry for the stm32f303
2021-01-01 Add joystick circuitry
2021-01-01 Add battery ADC voltage divider
2021-01-01 Add ws2812b LEDs
2021-01-01 Add cubemx project
2021-01-01 Add SWD header
2021-01-02 Add pushbuttons with debouncers
2021-01-02 Tidy up schematic
2021-01-03 Update cubemx pinouts
2021-01-03 Add testpoints
2021-01-03 Annotate all components
2021-01-03 Make ERC pass
2021-01-06 Assign footprints
2021-01-06 Combine libraries into single library
2021-01-07 Add high level board layout
2021-01-07 Group components in layout
2021-01-11 Update switches and battery
2021-01-11 Initial layout of components
2021-01-11 Make board square
2021-01-11 Shink down PCB dimensions
2021-01-11 Routing!
2021-01-15 Add text annotations to PCB
2021-01-16 Add mounting holes
2021-01-16 Round off board corners
2021-01-16 Use shorter power switch
2021-01-16 Tidy up silkscreen and traces
2021-01-16 Reverse the backwards zener diode
2021-01-16 Update cubemx project
2021-01-23 Add kicad gitignore
2021-01-23 Update component values for BOM
2021-01-24 fw: Add cortex-m-quickstart template
2021-01-24 fw: Add configuration for running on hardware
2021-01-24 fw: Split project into library and binary
2021-01-24 fw: Create board struct
2021-01-24 fw: Add function to set random tile to 2 or 4
2021-01-26 fw: Implement blinky!
2021-01-26 fw: Implement blinky on a single WS2812 led
2021-01-27 fw: Generate random tiles on 2048 board
2021-01-28 fw: Remove cortex-m-quickstart examples
2021-01-28 fw: Add joystick demo
2021-01-30 fw: Add buttons to input demo
2021-01-30 fw: Add 2048 tile colouring
2021-01-30 fw: Add logic for moving tiles
2021-06-02 fw: Add (hacked together but functional) 2048 game
2021-06-02 pcb: Remove crystal
2021-06-02 pcb: Add AT24C08D EEPROM to schematic
2021-06-02 pcb: Make routing changes to facilitate EEPROM
2021-06-02 pcb: Make mounting holes M3/general tidy
2021-06-07 pcb: Charge battery/power stuff independent of one another
2021-06-11 pcb: Tidy up routing
2021-06-12 fw: Add scoring
2021-06-26 fw: Update stm32f3 hal to 0.7.0
2021-06-29 fw: Use naive RTIC implementation
2021-06-30 fw: Add RTIC gpio interrupt test
2021-06-30 fw: Update periodically with a software task
2021-06-30 fw: Use interrupts for movement inputs
2021-07-11 fw: Fix panic on large gaps between moves
2021-07-11 fw: Improve differentiability of colours
2021-07-12 fw: Further improve colours
2021-07-12 fw: Fix flicker caused by interrupts during LED write
2021-09-24 pcb: Update version and changelog
2021-09-25 fw: Update pins for V2 pcb
2022-01-16 feat: Add eeprom r/w demo
2022-07-17 Update crates to latest versions
2022-07-17 fw: Store/read game state on EEPROM
2022-07-19 fw: Fix unintended reset due to delayed reset pin pull-up
